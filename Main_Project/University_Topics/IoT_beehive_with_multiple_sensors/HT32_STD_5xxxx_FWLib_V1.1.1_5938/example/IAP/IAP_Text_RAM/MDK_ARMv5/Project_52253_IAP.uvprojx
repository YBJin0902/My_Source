# Keil uVision project Project_52253_IAP.uvprojx, settings and files
target IAP (ARM-ADS)
  device: HT32F52253 Holtek
  pack: Holtek.HT32_DFP.1.0.21
  cpu: IROM(0x00000000-0x0001FBFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IAP +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52253_SK, USE_HT32F52243_53, USE_MEM_HT32F52253
  c include: ..\Src_IAP;..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=5
  library: MicroLIB
  scatter file: .\linker_iap.lin
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_ht32f5xxxx_01_it.c iap_handler.c iap_xmodem.c iap_buffer.c iap_crc16.c
  group Config
    ../Src_IAP/: ht32f5xxxx_conf.h
    ./: HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_IAP/: iap_system_ht32f5xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01_iap.s
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_div.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
