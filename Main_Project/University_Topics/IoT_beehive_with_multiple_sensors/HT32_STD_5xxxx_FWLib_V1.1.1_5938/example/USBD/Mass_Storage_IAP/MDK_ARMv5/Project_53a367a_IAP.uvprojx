# Keil uVision project Project_53a367a_IAP.uvprojx, settings and files
target IAP (ARM-ADS)
  device: HT32F52367 Holtek
  pack: Holtek.HT32_DFP.1.0.21
  cpu: IROM(0x00000000-0x0003FBFF) IRAM(0x20000000-0x20007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: IAP +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_BM53A367A_DVB, USE_HT32F52357_67, USE_MEM_HT32F52367
  c include: ..\Src_IAP;..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=11
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../Src_IAP/: iap_main.c iap_ht32f5xxxx_01_it.c iap_ht32_usbd_class.c iap_ht32_usbd_descriptor.c iap_usb_bulk_only_transport.c iap_usb_scsi_block_command.c
    ./: iap_flash_disk.lib iap_handler.lib
  group Config
    ../Src_IAP/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h
    ./: HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../Src_IAP/: iap_system_ht32f5xxxx_03.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_03_iap.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_aes.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_dac.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Doc
    ../: readme.txt
